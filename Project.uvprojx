# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: U:\coe718\project\common\src;U:\coe718\project\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: core_cm3.c Blinky.c IRQ.c GLCD_SPI_LPC1700.c LED.c LED.h KBD.c KBD.h adcuser.c adcuser.h audio.h type.h usb.h usbaudio.h usbcfg.h usbcore.c usbcore.h usbdesc.c usbdesc.h usbdmain.c usbhw.c usbhw.h usbreg.h usbuser.c usbuser.h ARM_Ani_16bpp.c Bg_16bpp_b.c Bg_16bpp_l.c Bg_16bpp_r.c Bg_16bpp_t.c Font_6x8_h.h Font_16x24_h.h GLCD.h startup_LPC17xx.s system_LPC17xx.c
  group New Group
    ./: img1.c game.c img2.c img3.c
software components: CMSIS:CORE 5.4.0
